options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: GFSK loopback
  states: {}

blocks:
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Anton\OneDrive - The University of Melbourne\MSP\Ground Station\repo\ground-station-v2\Signal Processing\receive.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Anton\OneDrive - The University of Melbourne\MSP\Ground Station\repo\ground-station-v2\Signal Processing\transmit.bin
    repeat: 'False'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '4'
    sensitivity: '1'
    verbose: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: Sent Signal
    size: '1024'
    srate: 2.4e6
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: Received Signal
    size: '1024'
    srate: 2.4e6
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_demod_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_mod_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_gfsk_mod_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']

metadata:
  file_format: 1
